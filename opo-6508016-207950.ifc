Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture], Option [IfcExportBaseQuantities: Off], Option [IfcExportElementOnOffAndFrozenLayers: On], Option [IfcExplodeExternalReferences: Off], Option [IfcTesselateBSplineCurvesAndSurfaces: Off], Option [IfcExportSweptSolidAsBRep: Off], Option [IfcExportProfileCenterOfGravity: Off], Option [IfcExportMultiPlyElementsAsAggregated: Off], Option [IfcExportTesselation: 0.000000], Option [IfcCreateUniqueGuidForBlocks: On], Option [IfcCreateUniqueGuidForXrefs: On], Option [IfcExportSubtractOpenings: Off], Option [IfcExportAllVisibilityStates: Off]
File name: E:\\OPO_Oeschger_AG\\CAD\\Artikel\\OPK_Europe_GmbH\\OPO_00_Opk_01_Master\\NeuBlock\\OPO_65.080.16.ifc
Time: 2026-01-14T06:26:30
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 26.1.05
Made in: BricsCAD BIM 26.1.05
Authorization: Undefined

# IfcSite, Standort
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Standort
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
